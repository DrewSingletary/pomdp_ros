Commit message: version for L-CSS

File: Gazebo/URDF/cast.urdf (robot description, URDF)
Before this commit: robot cast_flying_arena, 1 links, 0 joints
Links:
- link world: geometry visual mesh filename=package://pomdp_ros/Gazebo/Meshes/cast_simple_2.dae scale=1 1 1
